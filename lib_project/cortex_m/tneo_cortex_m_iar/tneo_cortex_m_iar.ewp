# IAR project tneo_cortex_m_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ../../../src; ../../../src/core; ../../../src/core/internal; ../../../src/arch
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../../src; ../../../src/core
  ILINK.IlinkOutputFile: kernel_cortex_m_iar.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group arch
    ../../../src/arch/cortex_m/: kernel_arch_cortex_m.S kernel_arch_cortex_m_c.c
  group core
    ../../../src/core/: kernel_dqueue.c kernel_eventgrp.c kernel_fmem.c kernel_list.c kernel_mutex.c kernel_sem.c kernel_sys.c kernel_tasks.c kernel_timer.c
