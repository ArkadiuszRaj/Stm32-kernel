# Keil uVision project tneo_cortex_m_keil5.uvprojx, settings and files
target kernel_cortex_m_keil5 (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: kernel_cortex_m_keil5 (library)
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c include: ..\..\..\src\core;..\..\..\src\core\internal;..\..\..\src;..\..\..\src\arch
  asm misc: --cpreproc
  asm include: ..\..\..\src;..\..\..\src\core
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group core
    ../../../src/core/: kernel_timer.c kernel_dqueue.c kernel_eventgrp.c kernel_fmem.c kernel_list.c kernel_mutex.c kernel_sem.c kernel_sys.c kernel_tasks.c kernel_timer_static.c kernel_timer_dyn.c
  group arch
    ../../../src/arch/cortex_m/: kernel_arch_cortex_m_c.c kernel_arch_cortex_m.S
